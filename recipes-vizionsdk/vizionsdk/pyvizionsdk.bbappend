# disable automatic file dependency scanning
SKIP_FILEDEPS:${PN} = "1"
