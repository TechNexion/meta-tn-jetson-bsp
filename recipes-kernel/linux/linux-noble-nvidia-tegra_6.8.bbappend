SRCBRANCH:tn-tek = "tn_l4t-r39.2.ga_kernel-6.8"
SRCREV:tn-tek = "${AUTOREV}"
KBRANCH:tn-tek = "${SRCBRANCH}"
SRC_REPO:tn-tek = "github.com/TechNexion-Vision/tn-jetson-kernel.git;protocol=https"

KBUILD_DEFCONFIG:tn-tek = "tegra_tn_defconfig"
